# IAR project emeter-app-67641.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430F67641A MSP430F67641A
  General.GStackSize2: 150
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: __MSP430__
  ICC430.newCCIncludePaths: ../../emeter-toolkit/include; ../../emeter-metrology/emeter-metrology-67641; ../../emeter-metrology/include; $PROJ_DIR$
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.ADefines: USE_LARGE_CODE_MODEL
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f67641a.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../: emeter-basic-display.c emeter-basic-oled.c emeter-basic-oled.h emeter-communication.c emeter-dlt645.c emeter-keypad.c emeter-lcd.c emeter-main.c emeter-multirate.c emeter-oled.c emeter-oled.h emeter-rtc-c.c emeter-setup.c
    ../../emeter-metrology/emeter-metrology-67641/Debug/Exe/: emeter-metrology-67641.r43
