# IAR project Backup (4) of emeter-toolkit-67641.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F67641 MSP430F67641
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: __MSP430__
  ICC430.newCCIncludePaths: ../include
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  A430.ADefines: USE_LARGE_CODE_MODEL
  A430.AUserIncludes: ../../emeter-toolkit/include
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  group (top)
    ../src/iar/: accum48.s43 bin2bcd16.s43 bin2bcd32.s43 bin2bcd64.s43 dc_filter16.s43 dc_filter24.s43 imul16.s43 imul16u.s43 isqrt16.s43 isqrt32.s43 isqrt64.s43 mac48.s43 mac64_16_24.s43 mul48_32_16.s43 mul48u_32_16.s43 q1_15_mul.s43 q1_15_mulr.s43 shift48.s43 sqac48_16.s43 sqac64_24.s43
    ../src/: dds.c div48.c div_sh48.c hal_pmm.c isqrt32i.c isqrt64i.c
