<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\emeter-app\emeter-app-67641\emeter-app-67641.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\emeter-metrology\emeter-metrology-67641\emeter-metrology-67641.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\emeter-toolkit\emeter-toolkit-67641\emeter-toolkit-67641.ewp</path>
  </project>
  <batchBuild/>
</workspace>


