# IAR project Backup (4) of emeter-metrology-67641.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F67641 MSP430F67641
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: __MSP430__
  ICC430.newCCIncludePaths: ../../emeter-toolkit/include; ../include; $PROJ_DIR$
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.ADefines: USE_LARGE_CODE_MODEL
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  group (top)
    ../../emeter-toolkit/emeter-toolkit-67641/Debug/Exe/: emeter-toolkit-67641.r43
    ../src/: metrology-background.c metrology-calibration-defaults.c metrology-corrections.c metrology-fir-table.c metrology-flash.c metrology-foreground.c metrology-readings.c metrology-setup.c
